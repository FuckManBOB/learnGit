# IAR project ucosii_pro.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430fn.h
  General.OGChipSelectMenu: MSP430F1611 MSP430F1611
  General.GStackSize2: 80
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.newCCIncludePaths: Src\; Src\HAL\; Src\MSP430Ports\; Src\OsKernel\
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F1611.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptLevel: 3
  XLINK.XclFile: lnk0t.xcl
  group APP
    Src/: app.c app_wd_handle.c app_wd_handle.h app_wdt.c app_wdt.h cmd_func.c cmd_func.h g_var_def.c g_var_def.h includes.h
  group CONFIG
    Src/: app_cfg.h os_cfg.h
  group HAL
    Src/HAL/: hal_battery.c hal_battery.h hal_board.c hal_board.h hal_ds18b20.c hal_ds18b20.h hal_flash.c hal_flash.h hal_isr.c hal_isr.h hal_lcd_tm1621.c hal_lcd_tm1621.h hal_rf.c hal_rf.h hal_time.c hal_time.h
  group KERNEL
    Src/OsKernel/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c ucos_ii.h
  group PORTS
    Src/MSP430Ports/: os_cpu.h os_cpu_a.asm os_cpu_c.c
